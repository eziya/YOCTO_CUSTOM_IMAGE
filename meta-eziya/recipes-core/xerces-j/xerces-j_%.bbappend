SRC_URI = "https://archive.apache.org/dist/xerces/j/source/Xerces-J-src.${PV}.tar.gz"

