SRC_URI = "https://www.multitech.net/mlinux/sources/jlex-1.2.6-Main.java;downloadfilename=${JLEX_MAIN_FILENAME} \
           file://jlex \
          "
